Commit message: updated URDF (fixed inertia and mass problem) (simplified collisions)

File: robots/dodo_daimao/urdf/dodo_daimao_simple.urdf (robot description, URDF)
Before this commit: robot dodo_daimao, 11 links, 10 joints
Links:
- link hip_left: mass 0 -> 0.428645410212592
